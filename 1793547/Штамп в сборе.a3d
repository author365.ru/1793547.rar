# KOMPAS-3D assembly (Штамп в сборе.a3d)

Referenced files in C:\Users\andrey\Desktop\Заказ 1793547 (Черч)\Дет. 85\: Матрица.m3d, Заготовка дет. 85.m3d, Пуансон.m3d
Texts:
  Штамп в сборе